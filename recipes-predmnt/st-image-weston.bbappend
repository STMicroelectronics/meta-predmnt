# Copyright (C) 2022, STMicroelectronics - All Rights Reserved

SUMMARY = "Recipe to increase rootfs partition"

ROOTFS_PARTITION_SIZE = "1232896"
IMAGE_ROOTFS_MAXSIZE = "${ROOTFS_PARTITION_SIZE}"
